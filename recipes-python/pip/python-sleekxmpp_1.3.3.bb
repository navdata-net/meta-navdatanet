inherit pypi setuptools
require python-sleekxmpp.inc
